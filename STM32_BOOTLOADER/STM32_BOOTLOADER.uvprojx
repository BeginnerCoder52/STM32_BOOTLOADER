# Keil uVision project STM32_BOOTLOADER.uvprojx, settings and files
target STM32_BOOTLOADER (6230000::V6.23::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32_BOOTLOADER +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: Drivers\Inc;Inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers/Inc
    ./Drivers/Inc/: stm32f103xx.h stm32f103xx_flash_driver.h stm32f103xx_gpio_driver.h stm32f103xx_rcc_driver.h stm32f103xx_spi_driver.h stm32f103xx_usart_driver.h
  group Drivers/Src
    ./Drivers/Src/: stm32f103xx_flash_driver.c stm32f103xx_gpio_drivers.c stm32f103xx_rcc_driver.c stm32f103xx_spi_driver.c stm32f103xx_usart_driver.c
  group Inc
    ./Inc/: bl_meta.h bootloader.h flash_if.h main.h stm32f1xx_hal_conf.h stm32f1xx_it.h
  group Src
    ./Src/: bootloader.c flash_if.c main.c syscalls.c sysmem.c watchdog.c
software components: CMSIS:CORE 6.1.0
